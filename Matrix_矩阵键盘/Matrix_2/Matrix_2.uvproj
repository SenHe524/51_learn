# Keil uVision project Matrix_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Matrix_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c LCD1602.c Matrix_2.c Matrix_Num.c DELAY.h LCD1602.h Matrix_Num.h
