# Keil uVision project Lcd_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Lcd_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Lcd_1.c TIMER0.h LCD1602.h DELAY.h Timer0.c LCD1602.c Delay.c
