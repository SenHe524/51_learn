# Keil uVision project Greedy snake.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Greedy snake +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Timer0.c Timer0.h main.c Show_74HC595.c Show_74HC595.h Matrix_Num.c Matrix_Num.h Delay.c DELAY.h
