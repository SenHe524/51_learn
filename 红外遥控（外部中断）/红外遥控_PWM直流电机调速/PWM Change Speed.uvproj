# Keil uVision project PWM Change Speed.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: PWM Change Speed +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c DELAY.h Nixie.c Nixie.h Timer1.c Timer1.h Int0.c Int0.h IR.c IR.h Timer0.c Timer0.h Motor.c Motor.h
