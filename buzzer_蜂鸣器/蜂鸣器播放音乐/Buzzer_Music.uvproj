# Keil uVision project Buzzer_Music.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Buzzer_Music +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c DELAY.h main.c Timer0.c Timer0.h
