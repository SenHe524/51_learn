# Keil uVision project I2C_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: I2C_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: I2C_1.c AT24C02.c Delay.c I2C.c LCD1602.c AT24C02.h DELAY.h I2C.h KEY.h LCD1602.h Show_74HC595.c Show_74HC595.h D_Scr.c D_Scr.h
