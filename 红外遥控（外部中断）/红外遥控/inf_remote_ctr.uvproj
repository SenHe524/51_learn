# Keil uVision project inf_remote_ctr.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: inf_remote_ctr +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LCD1602.c LCD1602.h main.c Delay.c DELAY.h Int0.c Int0.h Timer0.c Timer0.h IR.c IR.h
