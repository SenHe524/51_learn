# Keil uVision project DS18B20_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS18B20_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AT24C02.c AT24C02.h I2C.c I2C.h Delay.c DELAY.h DS18B20.c DS18B20.h LCD1602.c LCD1602.h main.c OneWire.c OneWire.h Timer0.c Timer0.h key_TIMER.c key_TIMER.h
