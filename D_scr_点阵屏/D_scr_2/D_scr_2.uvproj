# Keil uVision project D_scr_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: D_scr_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: D_scr_2.c Show_74HC595.c Show_74HC595.h DELAY.h Delay.c
