# Keil uVision project 111.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 111 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c DELAY.h key_TIMER.c key_TIMER.h main.c Matrix_Timer.c Matrix_Timer.h Nixie_Timer.c Nixie_Timer.h Timer0.c Timer0.h
