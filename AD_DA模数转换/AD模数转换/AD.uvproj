# Keil uVision project AD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c DELAY.h LCD1602.c LCD1602.h main.c XPT2046.h XPT2046.c
