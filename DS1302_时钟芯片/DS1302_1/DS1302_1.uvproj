# Keil uVision project DS1302_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS1302_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DS1302_1.c Delay.c DELAY.h LCD1602.c LCD1602.h DS1302_Fuction.c DS1302_Fuction.h
