# Keil uVision project DS18B20_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS18B20_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DELAY.h key.h LCD1602.h Timer0.h Delay.c key.c LCD1602.c Timer0.c main.c OneWire.c OneWire.h DS18B20.h DS18B20.c
