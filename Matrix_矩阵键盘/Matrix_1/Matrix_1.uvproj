# Keil uVision project Matrix_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Matrix_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Matrix_1.c Delay.c LCD1602.c DELAY.h LCD1602.h Nixie.c NIXIE.h Matrix_Num.c Matrix_Num.h
