# Keil uVision project Clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Matrix_Timer.c Matrix_Timer.h Nixie_Timer.c Nixie_Timer.h Timer0.c Timer0.h UART.c UART.h main2.c
