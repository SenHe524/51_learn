# Keil uVision project Stopwatch.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Stopwatch +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: key_TIMER.c key_TIMER.h main.c Nixie.c Nixie.h Timer0.c Timer0.h Delay.c DELAY.h AT24C02.c AT24C02.h I2C.c I2C.h
